<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/iqmathlib_ex2_functional.ewp</path>
  </project>
  <batchBuild/>
</workspace>
