<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/iqmathlib_ex3_fft.ewp</path>
  </project>
  <batchBuild/>
</workspace>
