# Keil uVision project boostxl_sensors_sensorGui_msp432p401r.uvprojx, settings and files
target boostxl_sensors_sensorGui_msp432p401r (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: boostxl_sensors_sensorGui_msp432p401r
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__
  c include: ..\..\..\..\..\..\source;..\..\..\..\..\..\source\third_party\CMSIS\Include;..;..\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../src/: bme280.c bme280.h bme280_support.c bme280_support.h bmi160.c bmi160.h bmi160_support.c bmi160_support.h demo_sysctl.c demo_sysctl.h i2c_driver.c i2c_driver.h main.c opt3001.c opt3001.h tmp007.c tmp007.h typedef.h uart_driver.c uart_driver.h
    ../: system_msp432p401r.c readme.txt
    ./: startup_msp432p401r_uvision.s
  group Library
    ../../../../../../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
